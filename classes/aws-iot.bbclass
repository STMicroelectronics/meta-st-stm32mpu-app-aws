../../../meta-digi-thud/meta-digi-dey/classes/aws-iot.bbclass