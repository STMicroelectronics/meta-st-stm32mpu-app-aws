
#LIC_FILES_CHKSUM = "file://LICENSE;md5=93645981214b60a02688745c14f93c95"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b748af41ef1300c98e105b3b7ec4ecc1"

#INFINEON
#SRCREV = "caf20c04651029626466c59d88b36c05cc6ea20b"
SRCREV = "a82d0709c97c88cc2e457ba111b6f51f21c22260"
